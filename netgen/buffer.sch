** sch_path: netgen/buffer.sch
**.subckt buffer VP VN A Y
*.iopin VP
*.iopin VN
*.ipin A
*.opin Y
X1 A net1 VP VN inverter
X2 net1 Y VP VN inverter
**.ends
.end
